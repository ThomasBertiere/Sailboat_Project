# Keil uVision project sailboat.uvproj, settings and files
target Simulation (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TP_GPIO
  group src
    ./src/: main.c
  group Boot
    C:/Keil/stm32lib/stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
  group services
    ../../services/src/: reception.c
    ../../Services/src/: battery.c weathercock.c servomotor.c rolling.c dcmotor.c
  group drivers
    ../../Drivers/src/: adc.c clock.c gpio.c timer.c Timer_Systick.c usart.c
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TP_GPIO
